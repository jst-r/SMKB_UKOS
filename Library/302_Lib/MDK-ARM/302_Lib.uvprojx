# Keil uVision project 302_Lib.uvprojx, settings and files
target 302_Lib (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F302R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: 302_Lib +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8
  c include: ../Core/Inc;  C:/Users/prizr/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.2/Drivers/STM32F3xx_HAL_Driver/Inc;  C:/Users/prizr/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.2/Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;  C:/Users/prizr/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.2/Drivers/CMSIS/Device/ST/STM32F3xx/Include;  C:/Users/prizr/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.2/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/User/Core
    ../Core/Src/: 6Step_Lib.c system_stm32f3xx.c UART_UI.c main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group New Group
    ../../../STM32CubeExpansion_SPN7_V1.1.0 — копия/Projects/Multi/Examples/MotorControl/Src/: stm32F302_nucleo_ihm07m1.c
  group Drivers/STM32F3xx_HAL_Driver
    C:/Users/prizr/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.2/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
software components: CMSIS:CORE 4.3.0
