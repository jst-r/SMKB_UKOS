# Keil uVision project STM32F302R8-Nucleo.uvprojx, settings and files
target STM32F302R8-Nucleo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F302R8-Nucleo Configuration +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8
  c misc: --C99 --reduce_paths
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\BSP\STM32F3xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM07M1;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\l6230;..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc;..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../../Src/: main_F302.c stm32f3xx_hal_msp.c stm32f3xx_it.c stm32F302_nucleo_ihm07m1.c
  group Example/MDK-ARM
    ./: startup_stm32f302x8.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/l6230/: l6230.c
  group Drivers/BSP/STM32F3xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F3xx-Nucleo/: stm32f3xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_IHM07M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM07M1/: X-NUCLEO-IHM07M1.c
  group Middlewares
    ../../../../../../Middlewares/ST/MC_6Step_Lib/Src/: 6Step_Lib.c
    ../../../../../../Middlewares/ST/UART_serial_com/Src/: UART_UI.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_dma.c
target STM32F302R8-Nucleo - DEMO mode (ARM-ADS)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: as above
  output: STM32F302R8-Nucleo Configuration
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8,DEMOMODE
  c misc: --C99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
target STM32F302R8-Nucleo - COMM mode (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: as above
  output: STM32F302R8-Nucleo Configuration
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8,UART_COMM
  c misc: --C99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
target STM32F302R8-Nucleo - BOOT mode (ARM-ADS)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: as above
  output: STM32F302R8-Nucleo Configuration
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8,BOOT
  c misc: --C99
  c include: as above
  memory RVCT4: ROM 0x800a000 size 0x6000
  memory RVCT9: RAM 0x20002000 size 0x2000
